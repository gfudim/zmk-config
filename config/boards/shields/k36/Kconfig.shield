## config/boards/shields/k36/Kconfig.shield
```kconfig
config SHIELD_K36_LEFT
	def_bool $(shields_list_contains,k36_left)

config SHIELD_K36_RIGHT
	def_bool $(shields_list_contains,k36_right)
```
